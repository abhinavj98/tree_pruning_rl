Commit message: Added tensorboard

File: ur_e_description/urdf/ur5e_original.urdf (robot description, URDF)
Before this commit: robot ur5e, 12 links, 11 joints
Joints:
- joint world_joint: origin xyz=0.0 0.0 0.0 rpy=0.0 0.0 3.14 -> xyz=0.0 0.0 0.0 rpy=0.0 0.0 0
